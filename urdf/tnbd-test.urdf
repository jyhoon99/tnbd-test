Commit message: first commit

File: urdf/tnbd-test.urdf (robot description, URDF)
Before this commit: robot tnbd-test, 7 links, 6 joints
Joints:
- joint left-wheel: type fixed -> continuous
- joint right-wheel: type fixed -> continuous
